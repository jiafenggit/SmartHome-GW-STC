# Keil uVision project MotherBoard.uvproj, settings and files
target SmartHomeNetWork (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: MotherBoard +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\include;..\..\..\..\PUB
  group Source
    ../Source/: AT24C16.C DeviceOperate.C IOH_RS485_BUS_Host.c main.c TimeAndDelay.C NetWork.C FlashOperate.C Linkage_Control.C
    ./: STARTUP.A51
    ../../../../pub/: IPA_EEPROM.C Read_MCU_Info.C
  group Doc
    ../Doc/: ReadMe.txt
